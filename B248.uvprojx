# Keil uVision project B248.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F405RG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.10.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: B248 +hex
  c flags: Optim=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F40XX
  c include: .\RTE\Device\STM32F405RG;.\RTE
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source
    ./: main.c main.h sin.h leds_step.c leds_step.h leds_modes.h leds_modes.c MAX5135.h MAX5135.c HC165.c HC165.h adc_pots_selector.c adc_pots_selector.h CAT25512.c dip_config.c expander.c
software components: CMSIS:CORE 3.30.0, Device:EXTI 1.0.0, Device:Startup 1.3.1, Device:StdPeriph Drivers:ADC 1.3.0, Device:StdPeriph Drivers:DAC 1.3.0, Device:StdPeriph Drivers:EXTI 1.3.0, Device:StdPeriph Drivers:Framework 1.3.1, Device:StdPeriph Drivers:GPIO 1.3.0, Device:StdPeriph Drivers:RCC 1.3.0, Device:StdPeriph Drivers:SPI 1.3.0, Device:StdPeriph Drivers:SYSCFG 1.3.0, Device:StdPeriph Drivers:TIM 1.3.0
